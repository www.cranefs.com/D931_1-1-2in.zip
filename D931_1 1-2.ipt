# Autodesk Inventor part: D931_1 1-2
## iProperties
Created: 2011-03
Part Number: D931_1 1-2
Document SubType Name: Modeling
Designer: D Cole
Density: 1 g/cm^3
Author: D Cole
